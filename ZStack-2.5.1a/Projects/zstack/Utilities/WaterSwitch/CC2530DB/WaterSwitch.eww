<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\WaterSwitch.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>WaterSwitch</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>WaterSwitch</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>WaterSwitch</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


